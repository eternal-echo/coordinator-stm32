# Keil uVision project async_uart.uvprojx, settings and files
target async_uart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: async_uart +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --gnu
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;..\Src\V4-SDK\V4-SDK\core\utils;..\Src\V4-SDK\V4-SDK\core\sysdep;..\Src\V4-SDK\V4-SDK\core;..\Src\V4-SDK\V4-SDK\components\ntp;..\Src\V4-SDK\V4-SDK\components\logpost
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Src/V4-SDK/V4-SDK/core/: aiot_mqtt_api.c aiot_state_api.c aiot_mqtt_api.h aiot_state_api.h aiot_sysdep_api.h aiot_http_api.c
    ../Src/V4-SDK/V4-SDK/core/sysdep/: core_stdinc.h core_sysdep.c core_sysdep.h
    ../Src/V4-SDK/V4-SDK/core/utils/: core_auth.c core_auth.h core_diag.c core_diag.h core_global.c core_global.h core_list.h core_log.c core_log.h core_mqtt.h core_sha256.c core_sha256.h core_string.c core_string.h core_http.c
    ../Src/V4-SDK/V4-SDK/components/ntp/: ntp_private.h aiot_ntp_api.h aiot_ntp_api.c
    ../Src/V4-SDK/V4-SDK/external/: ali_ca_cert.c
    ../Src/V4-SDK/V4-SDK/components/logpost/: aiot_logpost_api.c
    ../Src/V4-SDK/V4-SDK/portfiles/freertos-at-modem-port/: freertos_tcp_modem_port.c mqtt_at_basic_demo.c aiot_at_api.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
